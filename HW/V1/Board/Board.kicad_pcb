# Repository pommen/scanner-and-weight

## KiCad design HW/V1/Board/Board.kicad_pcb

Parts:
A1: Arduino_Nano_v2.x; Arduino_Nano
C1: 10uF/50V; CP_Elec_6.3x5.3
C2, C4, C5, C6, C7: 100n; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder
C3: 22uF/16V; CP_Elec_6.3x5.3
D1: D_Schottky; D_SMB_Handsoldering
F1: 30V/1100mA; Fuse_2920_7451Metric_Pad2.10x5.45mm_HandSolder
H1, H2, H3, H4: MountingHole; MountingHole_3.2mm_M3_DIN965
J1: Barrel_Jack; BarrelJack_Horizontal
J2: Screw_Terminal_01x04; TerminalBlock_bornier-4_P5.08mm
J3: Screw_Terminal_01x02; TerminalBlock_bornier-2_P5.08mm
J4: ToScanner; DSUB-9_Female_Horizontal_P2.77x2.84mm_EdgePinOffset7.70mm_H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
J5: i2cLCD; PinSocket_1x04_P2.54mm_Vertical
J6: toScale; TerminalBlock_bornier-4_P5.08mm
Q1, Q4, Q7: IRF7306TRPBF; SO-8_5.3x6.2mm_P1.27mm
Q2, Q3, Q5, Q6, Q8: BSS138; SOT-23
R1, R2, R3, R4, R5, R6, R7: 10K; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder
RN1, RN2, RN3: R_Network05; R_Array_SIP6
U1: V7805-1000; 3-SIP_Module_V7805-1000; MPN V7805-1000; Digi-Key_PN 102-1715-ND
U2: 74HC14; SOIC-14_3.9x8.7mm_P1.27mm
U3: HX711_Module
enc1: Rot_enc; PinSocket_1x05_P2.54mm_Vertical

Connections:
+5V: A1.27 (+5V), C2.2, C3.1, C4.2, C5.2, C6.2, C7.2, J4.3, J5.2, R6.1, R7.1, U1.3 (Vo+), U2.14 (VCC), U3.4 (VCC), enc1.5; also elsewhere on the board
+24V: C1.1, D1.1 (K), F1.2, Q1.1 (S), Q1.3 (S), Q4.1 (S), Q4.3 (S), Q7.1 (S), RN2.1 (common), U1.1 (Vin+)
BTN: RN1.4 (R3), U2.1, enc1.3
ENCA: RN1.2 (R1), U2.5, enc1.1
ENCB: RN1.3 (R2), U2.3, enc1.2
GND: A1.4 (GND), A1.19 (A0), A1.20 (A1), A1.29 (GND), C1.2, C2.1, C3.2, C4.1, C5.1, C6.1, C7.1, D1.2 (A), J1.1, J3.1, J4.0, J4.1, J5.1, Q2.2 (S), Q3.2 (S), Q5.2 (S), Q6.2 (S), Q8.2 (S), RN1.1 (common), RN3.1 (common), U1.2 (GND), U2.7 (GND), U3.1 (GND)
L1: A1.12 (D9), Q2.1 (G), RN3.6 (R5)
L2: A1.13 (D10), Q3.1 (G), RN3.5 (R4)
L3: A1.14 (D11), Q5.1 (G), RN3.4 (R3)
L4: A1.15 (D12), Q6.1 (G), RN3.3 (R2)
unnamed: A1.9 (D6), U2.2
unnamed: A1.10 (D7), U2.4
unnamed: A1.11 (D8), U2.6
unnamed: F1.1, J1.2
unnamed: J2.1, Q4.5 (D), Q4.6 (D)
unnamed: J2.2, Q4.7 (D), Q4.8 (D)
unnamed: J2.3, Q1.5 (D), Q1.6 (D)
unnamed: J2.4, Q1.7 (D), Q1.8 (D)
unnamed: J3.2, Q7.7 (D), Q7.8 (D)
unnamed: J6.1, U3.5 (E+)
unnamed: J6.2, U3.6 (E-)
unnamed: J6.3, U3.7 (A-)
unnamed: J6.4, U3.8 (A+)
unnamed: Q2.3 (D), R1.2
unnamed: Q3.3 (D), R2.2
unnamed: Q5.3 (D), R3.2
unnamed: Q6.3 (D), R4.2
unnamed: Q8.3 (D), R5.2
PullupsBuzzer: Q7.2 (G), R5.1, RN2.6 (R5)
PullupsL1: Q1.2 (G), R1.1, RN2.2 (R1)
PullupsL2: Q1.4 (G), R2.1, RN2.3 (R2)
PullupsL3: Q4.2 (G), R3.1, RN2.4 (R3)
PullupsL4: Q4.4 (G), R4.1, RN2.5 (R4)
SCL: A1.24 (A5), J5.4, R6.2
SDA: A1.23 (A4), J5.3, R7.2
scaleCLK: A1.8 (D5), U3.3 (SCK)
scaleDATA: A1.7 (D4), U3.2 (DT)
scannerCLK: A1.5 (D2), J4.7
scannerDATA: A1.6 (D3), J4.9

Notes on the sheet:
To barcode scanner. PS2 interface
DISP
Scale interface

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
Board: 2 copper layers, 99.7 x 70.1 mm, 44 parts (25 on the bottom side), 41 nets.

Other parts of the board:
H2#2, H2#3, H2#4: MountingHole; MountingHole_3.2mm_M3_DIN965
JP1, JP2: Jumper; R_Axial_Power_L20.0mm_W6.4mm_P25.40mm

Their connections:
+5V: JP2.1, JP2.2; also elsewhere on the board

## Commit log

2018-11-23 snart klar
2018-11-26 Kicad
2018-11-27 Better visuals
2018-11-27 Done with EEPROM
2018-11-27 Starting on the board
2018-11-28 Done
2018-11-29 Fixed bugs
2018-11-30 new layout
2019-01-09 old live
2019-01-09 Debug features and local libs
